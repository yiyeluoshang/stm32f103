# Keil uVision project stm32_f103.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\ARM;..\SoureFiles\App;..\SoureFiles\Bsp;..\SoureFiles\Drv
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../SoureFiles/App/: main.c hmi_app.c
  group Driver
    ../SoureFiles/Bsp/: key.c led.c usart.c
    ../SoureFiles/Drv/: stm32f10x_it.c systick.c
  group Arm
    ../ARM/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_rtc.c stm32f10x_tim.c
